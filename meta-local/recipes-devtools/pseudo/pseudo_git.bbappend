SRCREV = "ba8887e5f1e922f866681ec7dec1a00b602a9328"
SRC_URI:remove = "file://0001-configure-Prune-PIE-flags.patch"
SRC_URI:remove = "file://older-glibc-symbols.patch"
