TF_A_TOOLS_PLATFORM = "stm32mp1"
